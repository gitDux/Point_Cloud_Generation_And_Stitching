# Keil uVision project V2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: V2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\project
  group Source Group 1
    ./: STARTUP.A51 Delay.c PWM.c Uart.c main.c
